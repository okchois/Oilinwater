# Repository okchois/Oilinwater

File README.md:

# Oilinwater — 오일 내 수분 트랜스미터

오일(유압유·윤활유·절연유·연료) 속 수분을 온라인으로 측정하는 트랜스미터 개발 프로젝트.

**프로젝트: HMT500(260313)** — 회로·PCB·거버 파일명과 PCB 마킹은 **HMT500(260313A)** (결정 #25).

- [결정 기록](docs/decision-log.md) — 확정 사항과 미결 사항 (MCU, DAC 대체 계획 등)
- [조사 보고서](docs/research-report.md) — 측정 원리, 경쟁 제품, 센서 소자, 회로/기구/펌웨어 설계, 교정, 인증, 로드맵
- [시장 조사 종합](docs/market/00-summary.md) — 세계 시장, 경쟁 제품·가격, 국내 시장, 포지셔닝 제안
- [E+E EE364 원문 요약](docs/reference/ee364-summary.md) — 구조 참고 제품의 치수, 사양, 핀맵, Modbus 맵
- [IST MK33 스터디](docs/reference/ist-mk33-study.md) — 데이터시트·응용노트·백서: 이슬점 95 °C 한계, 온도 보정식, DC 없는 교류 구동, 취급·교정 지침
- [HMT500(260313) 기구 설계 Rev F](hardware/mech/README.md) — 제작 도면 PDF(조립도·부품도 4장), 3D STEP, 렌더 (두텍 SUS 오일 필터 캡 390000-001100 + HTX99R 센서 커넥터 + 교체형 센서 프로브, 피드스루 없이 Ø7 관통 + JST SH 하네스, 나사 M28×1 + O링, PCB 1장)
- [HMT500 기구설계 견적 요청서 (PDF)](docs/mech/HMT500_RFQ.pdf) · [도면 HMT500-M-000](docs/mech/HMT500-M-000.pdf)
- [기구 설계안](docs/mech/mechanical-design.md) — EE364형 일체형 구조도, 압력 격벽, 밀봉, 열, 원가
- [KiCad 회로도 HMT500(260313A)](hardware/kicad/README.md) — 계층 시트 6장, 심볼 라이브러리, BOM, PDF
- [회로도 검토 HMT500(260313A)](docs/hw/schematic-review-260313A.md) — 심볼·데이터시트 대조, 최적화 계획 (승인 대기)
- [회로 설계서 (서지·오결선 보호)](docs/hw/circuit-design.md) — 전원 eFuse, 출력 보호, RS-485 ±70 V, 접지, MCU 핀 할당
- [하드웨어 블록 설계](docs/hw/hardware-block-design.md) — 회로 블록도, 부품 선정, 아날로그 2ch + RS-485
- [MCU 선정 검토](docs/hw/mcu-selection.md) — STM32L431 재검토, 후보 비교, 교차 검토 질문지
- [사내 사용 부품 적용 검토](docs/hw/inhouse-parts.md) — MCU·DAC 구매 이력, DAC8760 → DAC7562 + 출력단 비교
- [습도 센서 선정](docs/hw/humidity-sensor-selection.md) — IST MK33-W mini 선정, P14·HYT 계열 비교
- [온도 센서 선정](docs/hw/temperature-sensor-selection.md) — IST MiniSens Pt1000 F0.1 선정, 2선식 검토
- [RS-485 + 부트로더 설계](docs/rs485-bootloader-design.md) — 기본 출력 RS-485 Modbus RTU, 통신으로 펌웨어 업데이트
- [`firmware/`](firmware/) — MCU 비의존 부트로더 코어 + PC 시뮬레이터
- [`tools/fwupdate.py`](tools/fwupdate.py) — 펌웨어 이미지 생성 및 RS-485 업데이트 도구
- [`tools/moisture_calc.py`](tools/moisture_calc.py) — 수분 활동도(aw) ↔ ppm 환산 참조 구현

```bash
python3 tools/moisture_calc.py --temp 20 --aw 0.5     # aw -> ppm
python3 tools/moisture_calc.py --temp 60 --ppm 20     # ppm -> aw
```

```bash
make -C firmware                               # 부트로더 시뮬레이터 빌드
python3 -m unittest discover -s tests          # 통합 테스트
python3 tools/fwupdate.py mkimage app.bin app.oiw --hw-id 1 --version 1.0.0
python3 tools/fwupdate.py flash app.oiw --port /dev/ttyUSB0 --addr 1   # pyserial 필요
```

## KiCad design hardware/kicad/HMT500(ED260313A)/HMT500(ED260313A).kicad_pcb

File hardware/kicad/README.md:

# HMT500(260313A) KiCad 회로도 v0.8

DOTECH HMT500(260313) 오일 수분 트랜스미터의 KiCad 회로도입니다.

**파일명·프로젝트 번호 = HMT500(260313A)** (결정 #25): 회로도·심볼·BOM·부품리스트·PDF, PCB 파일, 거버(`HMT500(260313A)-F_Cu.gtl` 등, 묶음 `HMT500(260313A).zip`), PCB 실크 마킹(아랫면 가운데) 모두 같은 이름을 씁니다. 거버 출력: `sh hardware/kicad/export_gerbers.sh`.

**v0.8 (결정 #26):** 모든 IC 핀을 제조사 데이터시트 원문으로 대조하고 반영했습니다 — [검토 문서](../../docs/hw/schematic-review-260313A.md).

설계 내용은 [회로 설계서](../../docs/hw/circuit-design.md)를 따릅니다.

| 파일 | 내용 |
|---|---|
| `HMT500(260313A)/HMT500(260313A).kicad_pro` | 프로젝트 (KiCad 7 형식 — KiCad 8/9에서 열면 자동 변환) |
| `HMT500(260313A)/HMT500(260313A).kicad_sch` | 최상위 시트 (하위 시트 6장) |
| `HMT500(260313A)/HMT500(260313A)_connector.kicad_sch` | 커넥터, 입력 서지 보호(TVS 2단, CM 초크), 하우징 접지(1 MΩ, 4.7 nF, GDT) |
| `HMT500(260313A)/HMT500(260313A)_power.kicad_sch` | eFuse TPS2660 (RTN은 GND와 분리, OVP 32.6 V / 복귀 30.1 V → 전원 12–28 V, v0.9), 벅 LMR36006BRNXR(5 V, L 15 µH·CFF 20 pF), LDO TPS7A2033(3.3 V) (v0.8) |
| `HMT500(260313A)/HMT500(260313A)_mcu.kicad_sch` | STM32G0B1CCT3 (LQFP48, −40~125 °C), SWD(TC2030), 리셋, 내부 온도센서. SPI1 = ADS1220, SPI2 = DAC(모드 3), SPI3 = PCAP04 (v0.8) |
| `HMT500(260313A)/HMT500(260313A)_measurement.kicad_sch` | J3 센서 하네스 커넥터(JST SH 1.0 4핀), PCAP04(QFN24 실제 핀, DC 없는 플로팅 모드) + 기준 C, ADS1220(Pt1000 2선) |
| `HMT500(260313A)/HMT500(260313A)_analog_out.kicad_sch` | DAC8760 ×2 (SCLK 게이트 U14, AVDD 10 Ω, ALARM wired-OR) + OPA197 +VSENSE 버퍼 + 외부 ISET-R + TPS26611DDFR 오결선 보호 + TVS3301 (v0.8) |
| `HMT500(260313A)/HMT500(260313A)_rs485.kicad_sch` | THVD2410 (±70 V), DE 10 k 풀다운 (v0.9) |
| `HMT500(260313A)/HMT500(260313A)_aux.kicad_sch` | v0.9 보조: TPS26611 +Vs 27 V 클램프, VIN 전압 감시, PCB에 넣지 못한 선택 사항 메모 |
| `HMT500(260313A)/HMT500(260313A).kicad_sym`, `sym-lib-table` | 프로젝트 심볼 라이브러리 |
| `HMT500(260313A)/HMT500(260313A)_BOM.csv` | 부품표 (값·풋프린트별 묶음) |
| `HMT500(260313A)/HMT500(260313A)_schematic.pdf` | 회로도 PDF (7쪽) |
| `HMT500(260313A)/HMT500(260313A)_parts_list.xlsx`, `.csv` | **구매용 부품리스트**: 회로도 부품 + 제조사·품번·1k 추정 단가·상태, 분류별 요약(환율 입력 시 원화 자동 계산). `make_parts_list.py`로 생성 |
| `HMT500(260313A)/HMT500(260313A).kicad_pcb` | 보드 외곽(57 × 23, 4층), 고정 구멍 2개, 금지 구역(홀더 홈·지지링 홈), **회로도 v0.9 부품 110개 배치·넷 지정 완료 (배선 전, 승인 대기)**. 설계 규칙: 간격·선폭 0.15, 비아 0.45/0.2, 가장자리 0.3, 넷클래스 CHASSIS 간격 1.0·선폭 0.5, J5 둘레 3.3 mm 부품 금지 |
| `HMT500(260313A)/placement.png`, `placement.json` | 배치 그림(윗면/아랫면, 색 = 기능 블록, 숫자 = 부품 높이)과 배치 표(기구 좌표) — 조립 시뮬레이션 입력 |
| `gen_pcb_outline.py` | 외곽·금지 구역 생성기. 치수는 `hardware/mech/hmt500_params.py`에서 읽습니다 |
| `place_pcb.py` | 부품 배치 (pcbnew). 고정 부품 + 큰 부품 자리표 + 작은 부품은 부모 패드 옆 빈 자리 탐색. 보드·금지 구역·하네스 플러그 통로·높이(보어) 조건 검사. `python3 place_pcb.py` |
| `plot_placement.py` | 배치 그림 (matplotlib) |
| `gen_footprints.py`, `lib/HMT500_260313A.pretty` | 프로젝트 풋프린트 (KiCad 7.0.11 복사본 + 자체 3종) |

## 도면 스타일 (v0.2)

- **흐름:** 신호는 왼쪽(입력) → 오른쪽(출력)으로 그리고, 전원은 위쪽 전원 심볼, GND는 아래쪽 GND 심볼로 표시합니다.
- **연결:** 시트 안은 실제 배선이고, 3선 이상 만나는 곳에는 접합점을 찍었습니다. 시트 사이 신호(SPI, 고장 신호, 커넥터 신호 등)만 전역 라벨로 잇습니다.
- **전원 심볼:** GND, +3V3, +3V3A(아날로그 3.3 V), +5V, VIN_P(보호된 입력), CHASSIS
- **구획:** 기능 블록마다 점선 구획, 제목, 설계 메모(설정 공식, 확인 항목)를 넣었습니다.
- **용지:** 커넥터·RS-485 시트는 A4, 나머지는 A3입니다.

## 생성과 검증

회로도는 `gen_hmt500.py`가 생성합니다. 각 부품에 설계 의도 넷(`nets=`)을 적고 배선은 좌표로 그립니다.
- **생성 단계 검사:** 선 중간에 걸친 핀, 연결 안 된 핀, 용지 밖, 표제란 침범이 있으면 생성이 멈춥니다.
- **연결 검사:** `check_netlist.py`가 KiCad 넷리스트와 설계 의도를 핀 단위로 대조합니다. 현재 74넷, 오류 0입니다.
- **자동 테스트:** `tests/test_kicad_gen.py`에 포함되어 있고, kicad-cli가 있으면 넷리스트 대조까지 수행합니다.

```bash
python3 hardware/kicad/gen_hmt500.py                     # 회로도·라이브러리·BOM 생성
kicad-cli sch export netlist -o hmt500.net hardware/kicad/HMT500(260313A)/HMT500(260313A).kicad_sch
python3 hardware/kicad/check_netlist.py hmt500.net       # 넷리스트 = 설계 의도 검사 (현재 74넷, 오류 0)
kicad-cli sch export pdf -o hardware/kicad/HMT500(260313A)/HMT500(260313A)_schematic.pdf hardware/kicad/HMT500(260313A)/HMT500(260313A).kicad_sch
```

KiCad 8 이상에서는 `kicad-cli sch erc`로 ERC도 실행할 수 있습니다(KiCad 7 CLI에는 ERC가 없음).

## 현재 상태와 주의 사항

- **편집 원본:** 스크립트로 다시 생성하면 KiCad에서 손으로 고친 내용이 덮어써집니다. **KiCad에서 편집을 시작하면 그 뒤로는 KiCad 파일을 원본으로 삼으십시오.**
- **핀 번호 확인 필요 (VERIFY=YES):** TPS2660, LMR36006, PCAP04, DAC8760, TPS26611.
  - 이 환경에서 제조사 데이터시트 사이트가 막혀 있어 **핀 번호를 가번호로** 넣었습니다. 핀 이름과 연결(넷)은 설계서대로입니다.
  - 데이터시트를 보고 심볼 핀 번호만 고치면 됩니다.
  - 확인한 부품: STM32G0B1CCT3(LQFP48, KiCad 공식 심볼 STM32G0B1C_B-C-E_Tx 기준), ADS1220(TSSOP-16), THVD2450(SOIC-8), TPS7A2033(SOT-23-5). 이 넷도 데이터시트로 한 번 더 대조하십시오.
- **풋프린트 TBD:** 공통모드 초크, GDT, 벅 인덕터, 가번호 IC 5종. (J3 `Connector_JST:JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal`, J1 `Connector_JST:JST_GH_SM08B-GHS-TB_1x08-1MP_P1.25mm_Horizontal`은 KiCad 표준. J5 샤시 스프링 접점 TBD)
- **확인할 회로 사항:**
  - DAC8760 VOUT/IOUT 결합과 DVDD-EN 극성
  - TPS26611 전압 모드 통과 여부
  - TPS2660 분압 기준전압(1.2 V 가정: UVLO 약 9 V, OVP 약 33 V)과 ILIM 저항값
  - LMR36006 FB 기준전압(1.0 V 가정 → 5.0 V)
  - PCAP04 플로팅 측정 결선(PC0–PC1 기준 C, PC2–PC3 센서)

Notes on the sheet:
Field connector, 2-stage bidirectional
TVS surge protection, chassis
isolation
eFuse (reverse/OV/UV), 60V buck to 5V,
LDO 3.3V
STM32G0B1CCT6, SWD, reset, internal
temperature sensor
Capacitive humidity sensor (PCAP04)
and Pt1000 2-wire (ADS1220)
2x DAC8760 V/I output with TPS26611
miswiring protection
THVD2410 +/-70V fault-protected
transceiver
AO supply VAO 16.1 V (buck), supply
monitor
DOTECH HMT500(ED260313A) - Oil Moisture Transmitter - Schematic v0.9 - Project No. HMT500(ED260313A)
File names (schematic, PCB, Gerber) = HMT500(ED260313A).* PCB silkscreen marking = HMT500(ED260313A)
Signal flow: J1 field connector -> protection -> eFuse -> 5 V buck -> 3.3 V LDO; sensor head J3 -> PCAP04 / ADS1220 -> MCU -> DAC8760 x2 / THVD2410 -> J1
Outputs: RS-485 Modbus RTU + 2x analog (4-20 mA / 0-20 mA / 0-10 V / 0-5 V selectable). Supply 12-28 V DC.
v0.11: stocked resistors R1/R3/R4/R5/R6; R3 845k, R5 35.7k, R6 82k; see decision #57.
v0.10: AO D30/D40 TVS1401 +/-14 V. AO +/-28/30 V continuous miswiring is NOT guaranteed (#41).
Power symbols: GND, +3V3, +3V3A (analog 3.3 V), +5V, VIN_P (protected input), CHASSIS. Inter-sheet signals: global labels.
History v0.3-v0.8 (MCU G0B1, JST harness, DAC8760/TPS26611 datasheet pinouts, RTN isolation, gated DAC SCLK ...): docs/decision-log.md #9-#26.
v0.9: 3-pass review (docs/hw/final-review-260313A.md): OVP 32.6 V (R5 36.5k); AO supply VAO 16.1 V buck U15 (DAC AVDD, TPS26611 +Vs; dec. #37, IVS320 AO); D3 series Schottky; RS-485 TVS D60/D61; D2 -> TVS3301; eFuse IN C2; buck CIN;
RS485_DE 10k pull-down (in-house bootloader, dec. #31); THVD2410; X7R only; R2 HV 1206; SGOOD -> PA0/PA4; CS_CDC -> PA15; VIN_SENSE PB0;
LATCH/CS pull-ups; OPA197 V+ = DAC AVDD; R31/R41 100k; SWD no-connect flags removed; sheet Aux: +Vs clamp, VIN monitor (DAC boost / HSE / sensor ESD: no room, dec. #32).
Footprints: KiCad 7.0.11 library + project library HMT500_260313A (GDT Bourns 2035-xx-SM, TVS3301 pad floating).
표기 규칙: 부품번호 = 굵은 글자 (R1, U4) / 부품값 = 보통 글자 (10k, DAC8760) / 전원 네트 = 기울인 글자 (+3V3, VIN_P)
신호 네트 = 테두리 있는 라벨 (SPI_SCK, OUT1_EXT) - 네트 이름은 부품번호·부품명과 겹치지 않게 지음
라벨 모양 = 신호 방향: 뾰족한 쪽이 밖 = 이 시트에서 내보냄(출력), 안 = 받음(입력), 양쪽 = 양방향, 네모 = 아날로그·수동
글자 겹침: 생성기가 부품 몸체·핀·선·라벨·메모와 겹치지 않는 자리에 자동 배치하고, 겹치면 생성 실패로 처리

Parts:
C1: 100n 100V; C_0805_2012Metric
C3: 4.7n 2kV; C_1812_4532Metric
D1: SMDJ36CA; D_SMC
D2: TVS3301DRBR; Texas_DRB0008A_PadFloat
D3: PMEG10010ELR; D_SOD-123F
GDT1: 2035-25-SM; GDT_Bourns_2035-xx-SM
J1: SM08B-GHS-TB; JST_GH_SM08B-GHS-TB_1x08-1MP_P1.25mm_Horizontal
J5: CHASSIS wire; SolderWire_Chassis_D0.6mm
L1: CMC 1mH 0.8A; L_CommonMode_Wuerth_WE-SL2
R1: 4.7R 1W 5%; R_2512_6332Metric
R2: 1M HV; R_1206_3216Metric

Connections:
CHASSIS: C3.1, GDT1.1, J5.1, R2.1
GND: C1.2, C3.2, D1.2, D2.5, D2.6, D2.7, D2.8, GDT1.2, L1.3, R2.2; also elsewhere on the board
GND_IN: J1.6 (GND), L1.2
OUT1_EXT: J1.4 (OUT1); also elsewhere on the board
OUT2_EXT: J1.5 (OUT2); also elsewhere on the board
RS485_A_EXT: J1.3 (RS485_A); also elsewhere on the board
RS485_B_EXT: J1.2 (RS485_B); also elsewhere on the board
VIN_D: D3.1; also elsewhere on the board
VIN_EXT: J1.8 (V+), L1.1
VIN_F: C1.1, D2.1, D2.2, D2.3, D2.4, D3.2, R1.2
VIN_L: D1.1, L1.4, R1.1

Notes on the sheet:
FIELD CONNECTOR
현장 커넥터
J1 JST GH 8P -> W-2 -> M12 8P
EE364 pinout, pin n = pin n
GH mounting pads (MP): PCB only
Pins 1, 7: not connected
INPUT SURGE / REVERSE-POLARITY PROTECTION
입력 서지·역극성 보호
TVS bidirectional: -30 V miswiring must not conduct
SMDJ (1st) -> R1 -> TVS3301 (2nd) -> D3 100 V Schottky -> eFuse (sheet Power)
CIRCUIT GND <-> CHASSIS (floating)
회로 GND–외함 분리
GDT conducts only on line-to-ground surge
PCB-housing creepage >= 2 mm
부품번호
특징 · 사양
SM08B-GHS-TB
현장 커넥터 연결
JST GH 1.25 mm 8P 옆 삽입, 하네스 W-2 → M12 8P, 핀 n = M12 핀 n
CMC 1mH 0.8A
전원선 공통모드 노이즈 차단
Bourns SRF0905-102Y (LCSC, 744222 동등), 2 × 1 mH, 0.8 A, 9.2 × 6 × 5.3 mm — 전도 방출·내성 대책
SMDJ36CA
입력 서지 1단 흡수
TVS 양방향 3000 W, 36 V — -30 V 오결선에 도통 안 함
4.7R 1W 5%
1단·2단 서지 분담
2512 1 W (Vishay CRCW2512, JLC 부품 — 결정 #38, 펄스 에너지 시험 T1)
TVS3301DRBR
입력 서지 2단 클램프
TI 평탄 클램프 ±33 V, 최대 42.5 V @ 27 A. DC 입력 33 V 초과 금지 (v0.9, 이전 SMBJ33CA)
PMEG10010ELR
음(-) 서지·역극성 차단
Nexperia 100 V 1 A 쇼트키 (저누설). D2가 -42.5 V로 잡는 동안 출력 쪽 +28 V → 역전압 약 71 V를 D3가 받음 → eFuse IN–OUT 역전압 없음 (외부 검수 H01). 손실 약 0.45 V × 0.1 A
GDT1
2035-25-SM
회로 GND–외함 서지 방전
Bourns 2전극 SMD GDT 250 V (LCSC), Ø5 × 4.4 mm — 선–대지 서지 때만 도통
C3, R2
4.7n 2kV / 1M HV

Parts:
C2: 2.2u 100V; C_1210_3225Metric
C4: 22n; C_0402_1005Metric
C5: 10u 50V; C_1206_3216Metric
C6: 22u 25V; C_1210_3225Metric
C8: 100n; C_0402_1005Metric
C12, C26: 1u; C_0402_1005Metric
C13: 10u; C_1206_3216Metric
C16: 220n 100V; C_0805_2012Metric
FB1: 600R@100MHz; L_0603_1608Metric
L2: 10uH; L_SXN_SMNR4020
R3: 845k 1%; R_0603_1608Metric
R4: 97.6k 1%; R_0603_1608Metric
R5: 35.7k 1%; R_0603_1608Metric
R6: 82k 1%; R_0603_1608Metric
R8: 118k 1%; R_0402_1005Metric
R9: 22.1k 1%; R_0402_1005Metric
U1: TPS26600PWPR; HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask2.46x2.31mm_The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
U2: LMR51606YFDBVR; SOT-23-6
U3: TPS7A2033PDBVR; SOT-23-5

Connections:
+3V3: C12.1, FB1.1, U3.5 (OUT); also elsewhere on the board
+3V3A: C13.1, FB1.2; also elsewhere on the board
+5V: C6.1, C26.1, L2.2, R8.1, U3.1 (IN), U3.3 (EN)
BUCK_BOOT: C8.1, U2.1 (CB)
BUCK_FB: R8.2, R9.1, U2.3 (FB)
BUCK_SW: C8.2, L2.1, U2.6 (SW)
EF_DVDT: C4.1, U1.12 (dVdT)
EF_ILIM: R6.1, U1.11 (ILIM)
EF_RTN: C4.2, R5.2, R6.2, U1.6 (MODE), U1.8 (RTN), U1.17 (RTN)
GND: C2.2, C5.2, C6.2, C12.2, C13.2, C16.2, C26.2, R9.2, U1.9 (GND), U2.2 (GND), U3.2 (GND); also elsewhere on the board
OV_DIV: R4.2, R5.1, U1.5 (OVP)
PWR_FLT: U1.14 (~FLT); also elsewhere on the board
UV_DIV: R3.2, R4.1, U1.3 (UVLO)
VIN_D: C2.1, R3.1, U1.1 (IN), U1.2 (IN); also elsewhere on the board
VIN_P: C5.1, C16.1, U1.15 (OUT), U1.16 (OUT), U2.4 (EN), U2.5 (VIN); also elsewhere on the board

Notes on the sheet:
eFuse TPS2660 reverse -60 V / OVP 32.6 V / UVLO 8.7 V
전자 퓨즈
R3/R4/R5 = 845k/97.6k/35.7k. UVLO rise 8.73 V; OVP rise 32.61 V, fall 30.14 V (nominal).
R6 = 82k: I_OL nominal 146 mA. Tolerance/leakage analysis: decision #57. TPS26611 +Vs = VAO 16.1 V.
EF_RTN = TPS2660 RTN reference: R5, R6, C4, MODE, PowerPAD. NEVER connect to GND (datasheet 9.3.5.5).
BUCK 5 V LMR51606 (4-65 V in, 0.6 A, 1.1 MHz)
5 V 강압 전원
Vout = 0.8 V x (1 + R8/R9) = 5.07 V. 1.1 MHz: L 10 uH, COUT 22 uF (SLUSEY1B Table 8-1). Same IC as U15.
LDO 3.3 V TPS7A2033 + analog rail +3V3A
3.3 V 레귤레이터
LOCAL INPUT CAPS
국부 입력 콘덴서
C16 at U2 VIN-GND, C5 (bulk) next to U2; C26 at U3 IN
부품번호
특징 · 사양
TPS26600PWPR
전자 퓨즈 (입력 보호)
역극성 -60 V 차단, 과전압 32.6 V (복귀 30.1 V)·저전압 8.9 V (R3–R5), 전류 제한 149 mA (R6), 돌입 제한 (C4), 고장 출력 FLT
2.2u 100V
eFuse 입력 콘덴서
TVS와 함께 IN ≥ 1 uF (데이터시트 11.1), U1 핀 옆 — 핫플러그 링잉 억제
EF_RTN
(기준 접지)
TPS2660 내부 기준
R5·R6·C4·MODE·방열 패드는 RTN에 연결. GND와 연결 금지 — 역극성 보호 무효·손상
LMR51606YFDBVR
5 V 강압 전원 (벅)
입력 4–65 V, 0.6 A 동기식, 1.1 MHz FPWM, SOT-23-6, 출력 = 0.8 V × (1 + R8/R9) = 5.07 V (결정 #38, JLC 부품, U15와 같은 IC)
L2, C6
10uH / 22u 25V
벅 출력 필터
SLUSEY1B 표 8-1 (5 V, 1.1 MHz: 10 uH, ≥ 10 uF). L2 SMNR4020-10UH 4 × 4 × 2 mm
C16 (+C5)
220n (+10u)
벅 입력 콘덴서
VIN–GND 핀 옆 220 nF, 벌크 C5 10 uF를 U2 옆에
TPS7A2033PDBVR
3.3 V 저잡음 레귤레이터
300 mA, 저잡음·높은 PSRR → 벅 리플 제거, SOT-23-5
FB1

Parts:
C14, C15, C20, C21: 100n; C_0402_1005Metric
C18: 4.7u; C_0805_2012Metric
J2: TC2030-IDC-NL; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
R10, R11: 10k; R_0402_1005Metric
R12, R13: 100k; R_0402_1005Metric
U4: STM32G0B1CCT6; LQFP-48_7x7mm_P0.5mm

Connections:
+3V3: C14.1, C15.1, C18.1, C20.1, J2.1 (VCC), R10.1, R11.1, R12.1, R13.1, U4.4 (VBAT), U4.5 (VREF+), U4.6 (VDD); also elsewhere on the board
ADC_DRDY: U4.21 (PB2); also elsewhere on the board
CDC_INT: U4.24 (PB12); also elsewhere on the board
CDC_MISO: U4.43 (PB4); also elsewhere on the board
CDC_MOSI: U4.44 (PB5); also elsewhere on the board
CDC_SCK: U4.42 (PB3); also elsewhere on the board
CS_ADC: R12.2, U4.20 (PB1); also elsewhere on the board
CS_CDC: R13.2, U4.37 (PA15); also elsewhere on the board
DAC1_LATCH: R10.2, U4.22 (PB10); also elsewhere on the board
DAC2_LATCH: R11.2, U4.23 (PB11); also elsewhere on the board
DAC_ALARM: U4.45 (PB6); also elsewhere on the board
DAC_MISO: U4.26 (PB14); also elsewhere on the board
DAC_MOSI: U4.27 (PB15); also elsewhere on the board
DAC_SCK: U4.25 (PB13); also elsewhere on the board
GND: C14.2, C15.2, C18.2, C20.2, C21.2, J2.5 (GND), U4.7 (VSS); also elsewhere on the board
NRST: C21.1, J2.3 (NRST), U4.10 (PF2-NRST)
OUT1_SGOOD: U4.11 (PA0); also elsewhere on the board
OUT2_SGOOD: U4.15 (PA4); also elsewhere on the board
PWR_FLT: U4.46 (PB7); also elsewhere on the board
RS485_DE: U4.12 (PA1); also elsewhere on the board
RS485_RX: U4.14 (PA3); also elsewhere on the board
RS485_TX: U4.13 (PA2); also elsewhere on the board
SPI_MISO: U4.17 (PA6); also elsewhere on the board
SPI_MOSI: U4.18 (PA7); also elsewhere on the board
SPI_SCK: U4.16 (PA5); also elsewhere on the board
SWCLK: J2.4 (SWCLK), U4.36 (PA14-BOOT0)
SWDIO: J2.2 (SWDIO), U4.35 (PA13)
VIN_SENSE: U4.19 (PB0); also elsewhere on the board

Notes on the sheet:
MCU DECOUPLING
MCU 바이패스
100 nF at VDD, VBAT, VREF+ (C20); 4.7 uF bulk
RESET
PWR_FLT: internal pull-up (PB7)
SGOOD low = OK -> PA0/PA4 (ADC)
PULL-UPS
SWD
생산 프로그래밍
MCU NOTES (STM32G0B1)
MCU 설정 메모
BOOT0 shares PA14/SWCLK - no pull-down.
Option bytes: nBOOT_SEL=1, nBOOT0=1, IWDG_SW=0, RDP 1
-> in-house RS-485 bootloader 0x08000000 (dec. #31).
VDDA = VDD (LQFP48); VREF+ tied to +3V3 (C20).
PCB temp (mid): internal sensor, ADC ch TS + TS_CAL.
Cortex-M0+: no SWO (J2 pin 6 NC).
Same die as DP2000 (G0B1CCT6); T3 = -40..125 C.
VIN_SENSE (PB0 ADC_IN8) = VIN_P / 11.
부품번호
특징 · 사양
STM32G0B1CCT6
제어·통신·보정 연산
Cortex-M0+ 64 MHz, 플래시 256 KB, RAM 144 KB, -40–85 °C (샘플 #39), LQFP48, 내부 온도센서 (PCB 온도). SPI1 = ADS1220, SPI2 = DAC (모드 3, SCLK 게이트), SPI3 = PCAP04
TC2030-IDC-NL
생산 때 펌웨어 기록 (SWD)
PCB 패드만 (부품 없음). 이후 업데이트는 RS-485 부트로더
C21
100n
리셋 노이즈 필터
NRST 핀, 몰딩 후 EMC 여유
R10, R11
10k
DAC LATCH 풀업
리셋 중 LATCH High → SCLK 게이트 닫힘, DAC 오입력 방지 (v0.9)
R12, R13
100k
CS 풀업
리셋 중 ADS1220·PCAP04 선택 해제 (디지털 입력 부동 금지)
주요 부품 — 역할 · 특징 · 사양

Parts:
C22: 330p C0G 2%; C_0603_1608Metric
C23, C28, C29: 100n; C_0402_1005Metric
C24: 22u 10V; C_1206_3216Metric
C25: 10u; C_1206_3216Metric
C27: 10n C0G; C_0603_1608Metric
J3: SM04B-SRSS-TB; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
R17, R18, R20: 1k; R_0402_1005Metric
R19: 4.02k 0.1% 25ppm; R_0603_1608Metric
U5: PCAP04-AQFM-24; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm
U6: ADS1220IPWR; TSSOP-16_4.4x5mm_P0.65mm

Connections:
+3V3: C28.1, U6.13 (DVDD); also elsewhere on the board
+3V3A: C23.1, C24.1, C29.1, U5.4 (VDD33), U5.14 (VDD33), U6.12 (AVDD); also elsewhere on the board
ADC_DRDY: U6.14 (~DRDY); also elsewhere on the board
CDC_INT: U5.11 (PG5); also elsewhere on the board
CDC_MISO: U5.10 (MISO); also elsewhere on the board
CDC_MOSI: U5.15 (MOSI); also elsewhere on the board
CDC_SCK: U5.16 (SCK); also elsewhere on the board
CDC_V18: C25.1, U5.3 (VDD18)
CREF_A: C22.1, U5.22 (PC0)
CREF_B: C22.2, U5.23 (PC1)
CS_ADC: U6.2 (~CS); also elsewhere on the board
CS_CDC: U5.9 (SSN); also elsewhere on the board
GND: C23.2, C24.2, C25.2, C28.2, C29.2, R20.2, U5.2 (GND), U5.8 (GND), U5.13 (IIC_EN), U5.25 (EP), U6.3 (CLK), U6.4 (DGND), U6.5 (AVSS); also elsewhere on the board
PT_N: J3.4 (PT-), R18.1, R19.1, U6.9 (REFP0)
PT_P: J3.3 (PT+), R17.1, U6.11 (AIN0/REFP1)
PT_SN_F: C27.2, R18.2, U6.7 (AIN2)
PT_SP_F: C27.1, R17.2, U6.10 (AIN1)
REF_N: R19.2, R20.1, U6.8 (REFN0)
SENS_C1: J3.1 (SENS_1), U5.24 (PC2)
SENS_C2: J3.2 (SENS_2), U5.1 (PC3)
SPI_MISO: U6.15 (DOUT/~DRDY); also elsewhere on the board
SPI_MOSI: U6.16 (DIN); also elsewhere on the board
SPI_SCK: U6.1 (SCLK); also elsewhere on the board

Notes on the sheet:
SENSOR HEAD J3
harness W-1 from HTX99R, JST SH 1.0
CAPACITIVE HUMIDITY SENSOR (IST MK) -> PCAP04
습도 센서 측정
Floating single mode (DC-free, datasheet 7.2): C22 on PC0/PC1, sensor on PC2/PC3. Own SPI3.
Pt1000 2-WIRE -> ADS1220 (ratiometric)
온도 측정 (2선식)
IDAC1 (AIN0) -> PT+ ; sense AIN1-AIN2, force/sense split at J3 pads
RC filter R17/R18/C27 ; Rref R19 on REFP0/REFN0 ; lead R removed by calibration
PCB temp: ADS1220 internal sensor (TS mode)
DECOUPLING
바이패스
부품번호
특징 · 사양
SM04B-SRSS-TB
센서 하네스 W-1 연결
JST SH 1.0 mm 4P 옆 삽입, 1·2 = MK33, 3·4 = Pt1000
PCAP04-AQFM-24
습도 센서 정전용량 측정
정전용량–디지털 변환, 기준 C와 비율 측정(방전 시간), DC 없는 구동, 내부 DSP, 전용 SPI3 (모드 1)
C25, C24
10u / 22u
PCAP04 전원 버퍼
VDD18 ≥ 4.7 uF, VDD33 ≥ 10 uF (데이터시트 표 2) — DC 바이어스 후에도 충족 (v0.9)
C22
330p C0G 2%
PCAP04 기준 용량
센서 MK33-W (300 pF, 결정 #33) 측정 범위 가운데 값, C0G
ADS1220IPWR
Pt1000 온도 측정
24비트 ADC, 50/60 Hz 제거, 내부 온도센서 (PCB 온도). 설정: IDAC = 250 uA 고정 (100 uA면 기준 0.40 V < 권장 0.75 V), PGA ≤ 2 (SPI1 모드 1)
R19
4.02k 0.1% 25ppm
Pt1000 비율 측정 기준저항
IDAC 전류 오차 상쇄, 온도계수 25 ppm/°C (결정 #38)
R17, R18, C27
1k / 10n C0G
입력 RC 필터
차동 노이즈 제거 (C0G, 데이터시트 9.2)
주요 부품 — 역할 · 특징 · 사양
