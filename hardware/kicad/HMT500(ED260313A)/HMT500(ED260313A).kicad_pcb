# Repository okchois/Oilinwater (continued)

## KiCad design hardware/kicad/HMT500(ED260313A)/HMT500(ED260313A).kicad_pcb (continued)

Parts:
C36, C40, C44, C50, C54: 100n; C_0402_1005Metric
C41, C51: 1n 100V; C_0603_1608Metric
C42, C45, C52, C55: 100n 50V; C_0805_2012Metric
C47, C57: 4.7n; C_0402_1005Metric
C48, C58: 100p C0G; C_0402_1005Metric
D30, D40: TVS1401DRBR; Texas_DRB0008A_PadFloat
D41, D51: BAS70-04; SOT-23
R30, R40: 10R pulse; R_2512_6332Metric
R31, R41: 100k; R_0402_1005Metric
R32, R42: 15k 0.1% 25ppm; R_0603_1608Metric
R33: 10k; R_0402_1005Metric
R34, R44: 10R; R_0402_1005Metric
U7, U8: DAC8760IPWP; HTSSOP-24-1EP_4.4x7.8mm_P0.65mm_EP3.2x5mm
U9, U10: TPS26611DDFR; SOT-23-8
U12, U13: OPA197IDBVR; SOT-23-5
U14: SN74LVC2G32DCUR; VSSOP-8_2.3x2mm_P0.5mm

Connections:
+3V3: C36.1, C44.1, C54.1, R33.1, U7.2 (DVDD), U8.2 (DVDD), U14.8 (VCC); also elsewhere on the board
DAC1_AVDD: C42.1, C45.1, D41.2 (K), R34.2, U7.24 (AVDD), U12.5 (V+)
DAC1_CMP: C47.2, C48.1, U7.17 (CMP)
DAC1_ISET: R32.1, U7.13 (ISET-R)
DAC1_LATCH: U7.7 (LATCH), U14.2 (1B); also elsewhere on the board
DAC1_OUT: C47.1, D41.3 (COM), U7.19 (IOUT), U7.21 (VOUT), U9.4 (IN)
DAC1_REF: C40.1, U7.14 (REFOUT), U7.15 (REFIN)
DAC1_SCLK: U7.8 (SCLK), U14.7 (1Y)
DAC1_SENSE: U7.22 (+VSENSE), U12.1 (OUT), U12.4 (-IN)
DAC2_AVDD: C52.1, C55.1, D51.2 (K), R44.2, U8.24 (AVDD), U13.5 (V+)
DAC2_CMP: C57.2, C58.1, U8.17 (CMP)
DAC2_ISET: R42.1, U8.13 (ISET-R)
DAC2_LATCH: U8.7 (LATCH), U14.6 (2B); also elsewhere on the board
DAC2_OUT: C57.1, D51.3 (COM), U8.19 (IOUT), U8.21 (VOUT), U10.4 (IN)
DAC2_REF: C50.1, U8.14 (REFOUT), U8.15 (REFIN)
DAC2_SCLK: U8.8 (SCLK), U14.3 (2Y)
DAC2_SENSE: U8.22 (+VSENSE), U13.1 (OUT), U13.4 (-IN)
DAC_ALARM: R33.2, U7.3 (~ALARM), U8.3 (~ALARM); also elsewhere on the board
DAC_MISO: U7.10 (SDO), U8.10 (SDO); also elsewhere on the board
DAC_MOSI: U7.9 (DIN), U8.9 (DIN); also elsewhere on the board
DAC_SCK: U14.1 (1A), U14.5 (2A); also elsewhere on the board
GND: C36.2, C40.2, C41.2, C42.2, C44.2, C45.2, C48.2, C50.2, C51.2, C52.2, C54.2, C55.2, C58.2, D30.5, D30.6, D30.7, D30.8, D40.5, D40.6, D40.7, D40.8, D41.1 (A), D51.1 (A), R32.2, R42.2, U7.1 (AVSS), U7.4 (GND), U7.5 (CLR-SEL), U7.6 (CLR), U7.11 (GND), U7.12 (GND), U7.16 (DVDD-EN), U7.23 (-VSENSE), U7.25 (EP), U8.1 (AVSS), U8.4 (GND), U8.5 (CLR-SEL), U8.6 (CLR), U8.11 (GND), U8.12 (GND), U8.16 (DVDD-EN), U8.23 (-VSENSE), U8.25 (EP), U9.1 (GND), U9.2 (MODE), U9.3 (-Vs), U10.1 (GND), U10.2 (MODE), U10.3 (-Vs), U12.2 (V-), U13.2 (V-), U14.4 (GND); also elsewhere on the board
OUT1_EXT: C41.1, D30.1, D30.2, D30.3, D30.4, R30.2, R31.2; also elsewhere on the board
OUT1_P: R30.1, U9.5 (OUT)
OUT1_SGOOD: U9.8 (SGOOD); also elsewhere on the board
OUT1_SNS: R31.1, U12.3 (+IN)
OUT2_EXT: C51.1, D40.1, D40.2, D40.3, D40.4, R40.2, R41.2; also elsewhere on the board
OUT2_P: R40.1, U10.5 (OUT)
OUT2_SGOOD: U10.8 (SGOOD); also elsewhere on the board
OUT2_SNS: R41.1, U13.3 (+IN)
VAO: R34.1, R44.1, U9.6 (+Vs), U10.6 (+Vs); also elsewhere on the board

Notes on the sheet:
ANALOG OUTPUT CH1 - V/I selectable, TVS +/-14 V -> connector pin 4
아날로그 출력 1
VOUT + IOUT one terminal (datasheet 9.1.1.3). +VSENSE = U12 OPA197 follower of terminal OUT1_EXT (after R30) via R31:
no +VSENSE 60k leakage in current mode, series-R drop corrected in voltage mode. ISET-R = R32 15k 0.1%. SGOOD low = OK.
CH1 DECOUPLING
채널 1 바이패스
C45: U12 V+. C47/C48: CMP. D41: DAC out clamp
ANALOG OUTPUT CH2 - V/I selectable, TVS +/-14 V -> connector pin 5
아날로그 출력 2
VOUT + IOUT one terminal (datasheet 9.1.1.3). +VSENSE = U13 OPA197 follower of terminal OUT2_EXT (after R40) via R41:
no +VSENSE 60k leakage in current mode, series-R drop corrected in voltage mode. ISET-R = R42 15k 0.1%. SGOOD low = OK.
CH2 DECOUPLING
채널 2 바이패스
C55: U13 V+. C57/C58: CMP. D51: DAC out clamp
DAC SELECTION (decision #10)
DAC 선정
U7/U8 fitted: DAC8760 (16-bit, I + V output).
Drop-in alternates (same pinout, no layout change):
DAC7760 12-bit, I + V (cost-down, V/I kept)
DAC8750 16-bit, I only 4-20/0-20/0-24 mA (EE364-equiv.)
DAC7750 12-bit, I only (~5 uA/step vs EE364 2 uA)
Current-only (x750): VOUT/+VSENSE/-VSENSE absent -
check pin handling before fitting (VERIFY).
DAC SPI - SPI2, SCLK gated per DAC
DAC 전용 SPI
DAC8760 rev D: daisy chain removed; multiple devices
need gated SCLK (datasheet 8.5.1.5, Fig. 8-9).
SPI2 mode 3 (CPOL 1, CPHA 1): SCK idles high, so the
OR gate gives no extra edge at LATCH low/high.
DACn_SCLK = DAC_SCK OR DACn_LATCH (PB10 / PB11).
DIN and SDO shared (SDO 3-state after LATCH).
ALARM: open drain, wired-OR, R33 10k pull-up;
which channel -> read status register.
부품번호
특징 · 사양
U7, U8
DAC8760IPWP
아날로그 출력 1·2
16비트, 4–20 / 0–20 / 0–24 mA · 0–5 / 0–10 V 선택, 내부 기준, 고장 알람 — 대체 DAC7760/8750/7750
U9, U10

Parts:
C60: 100n; C_0402_1005Metric
D60, D61: TVS3301DRBR; Texas_DRB0008A_PadFloat
R60: 10k; R_0402_1005Metric
U11: THVD2410DGKR; VSSOP-8_3.0x3.0mm_P0.65mm

Connections:
+3V3: C60.1, U11.8 (VCC); also elsewhere on the board
GND: C60.2, D60.5, D60.6, D60.7, D60.8, D61.5, D61.6, D61.7, D61.8, R60.2, U11.5 (GND); also elsewhere on the board
RS485_A_EXT: D60.1, D60.2, D60.3, D60.4, U11.6 (A); also elsewhere on the board
RS485_B_EXT: D61.1, D61.2, D61.3, D61.4, U11.7 (B); also elsewhere on the board
RS485_DE: R60.1, U11.2 (~RE), U11.3 (DE); also elsewhere on the board
RS485_RX: U11.1 (R); also elsewhere on the board
RS485_TX: U11.4 (D); also elsewhere on the board

Notes on the sheet:
RS-485 (Modbus RTU) - bus pins +/-70 V fault protected
RS-485 통신
No termination on board (fit at bus ends). Fail-safe receiver built in.
D60/D61 TVS3301: bus surge (1 kV / 42 ohm ~ 24 A < 27 A), +/-33 V standoff keeps +/-30 V miswiring.
부품번호
특징 · 사양
U11
THVD2410DGKR
RS-485 (Modbus RTU) 통신
VSSOP-8 (SOIC와 같은 핀), 3.3 V 반이중 500 kbps (느린 에지 → EMC·반사 유리, v0.9), 버스 핀 ±70 V 고장 보호, IEC ESD 보호 내장, 버스 개방 시 안전 수신
R60
10k
DE 풀다운
MCU 리셋·부팅·부트로더 점프 중 송신기 OFF·수신 ON (자체 부트로더 필수, 결정 #31)
C60
100n
전원 바이패스
U11 VCC
D60, D61
TVS3301DRBR
버스 A/B 서지 클램프
±33 V 평탄 클램프, 최대 42.5 V @ 27 A — THVD2410 ±70 V 안, ±30 V 오결선에 도통 안 함 (외부 검수 H02)
주요 부품 — 역할 · 특징 · 사양
* 표시 값은 데이터시트로 확인

Parts:
C30, C63: 100n; C_0402_1005Metric
C46, C56, C62: 100n/50V; C_0603_1608Metric
C61: 2.2u 50V; C_0805_2012Metric
C64, C65: 10u 50V; C_1206_3216Metric
L3: 22uH; L_SXN_SMNR4020
R14: 100k 1%; R_0402_1005Metric
R15: 10k 1%; R_0402_1005Metric
R51: 422k 1%; R_0402_1005Metric
R52: 22.1k 1%; R_0402_1005Metric
U15: LMR51606YFDBVR; SOT-23-6

Connections:
GND: C30.2, C46.2, C56.2, C61.2, C62.2, C64.2, C65.2, R15.2, R52.2, U15.2 (GND); also elsewhere on the board
VAO: C46.1, C56.1, C64.1, C65.1, L3.2, R51.1; also elsewhere on the board
VAO_CB: C63.1, U15.1 (CB)
VAO_FB: R51.2, R52.1, U15.3 (FB)
VAO_SW: C63.2, L3.1, U15.6 (SW)
VIN_P: C61.1, C62.1, R14.1, U15.4 (EN), U15.5 (VIN); also elsewhere on the board
VIN_SENSE: C30.1, R14.2, R15.1; also elsewhere on the board

Notes on the sheet:
AO SUPPLY VAO 16.1 V - DC-DC (decision #37)
VAO = 0.8 V x (1 + 422k/22.1k) = 16.08 V (15.5-16.6 V). LMR51606 FPWM 1.1 MHz, max duty 98 %.
Load 2 x (DAC 27 + OPA197 1.3 + TPS26611 1.75 mA) = 60 mA. C46/C56 at U9/U10 pin 6.
VIN_P < ~17 V: VAO follows VIN_P (dropout). 24 mA x 500 ohm OK down to VIN ~15.8 V.
SUPPLY MONITOR
전원 전압 감시
VIN_SENSE = VIN_P / 11 -> PB0 (ADC_IN8)
OPTIONS NOT FITTED ON PCB
PCB에 넣지 않은 선택 사항
DAC8760 IOUT boost: not needed - AVDD = VAO 16.1 V (decision #37) cuts DAC heat
from about 0.66 W to 0.39 W per channel (24 mA short, any supply 12-28 V).
Thermal test on a potted prototype still planned.
HSE crystal: no room next to PF0/PF1 -> factory HSI trim + firmware HSI calibration
from Modbus frame timing (USART auto-baud / timer capture).
Sensor-line ESD array: no room next to J3 -> probe ESD test (IEC 61000-4-2) decides;
if needed: protect at the HTX99R side or in the next PCB rev.
부품번호
특징 · 사양
U15
LMR51606YFDBVR
AO 전원 VAO 16.1 V 벅
4–65 V 입력 0.6 A, 1.1 MHz FPWM, SOT-23-6 — DAC AVDD·TPS26611 +Vs·OPA197 V+ 공용 (IVS320 AO rev 1.0과 같은 회로, 결정 #37)
L3, C64, C65
22uH / 10u 50V ×2
벅 출력
22 uH 1.05 A 4 × 4 × 2 mm, 10 uF 50 V X7R 1206 × 2 (16 V에서 실효 약 4 uF × 2)
R51, R52
422k / 22.1k 1%
VAO 설정
0.8 V × (1 + 422/22.1) = 16.08 V
C61, C62, C63
2.2u 50V / 100n / 100n
입력·부트스트랩
VIN 핀 옆 입력 C, CB–SW 100 nF
C46, C56
100n/50V
+Vs 바이패스
C46 → U9 6번, C56 → U10 6번 핀 옆
R14, R15, C30
100k / 10k / 100n

Board: 6 copper layers, 56.5 x 23.0 mm, 110 parts (71 on the bottom side), 81 nets.

File hardware/kicad/HMT500(ED260313A)/HMT500(ED260313A)_BOM.csv:

Qty,References,Symbol,Value,Footprint,Verify
1,C1,C,100n 100V,Capacitor_SMD:C_0805_2012Metric,
1,C2,C,2.2u 100V,Capacitor_SMD:C_1210_3225Metric,
1,C3,C,4.7n 2kV,Capacitor_SMD:C_1812_4532Metric,
1,C4,C,22n,Capacitor_SMD:C_0402_1005Metric,
3,C5 C64 C65,C,10u 50V,Capacitor_SMD:C_1206_3216Metric,
1,C6,C,22u 25V,Capacitor_SMD:C_1210_3225Metric,
16,C8 C14 C15 C20 C21 C23 C28 C29 C30 C36 C40 C44 C50 C54 C60 C63,C,100n,Capacitor_SMD:C_0402_1005Metric,
2,C12 C26,C,1u,Capacitor_SMD:C_0402_1005Metric,
2,C13 C25,C,10u,Capacitor_SMD:C_1206_3216Metric,
1,C16,C,220n 100V,Capacitor_SMD:C_0805_2012Metric,
1,C18,C,4.7u,Capacitor_SMD:C_0805_2012Metric,
1,C22,C,330p C0G 2%,Capacitor_SMD:C_0603_1608Metric,
1,C24,C,22u 10V,Capacitor_SMD:C_1206_3216Metric,
1,C27,C,10n C0G,Capacitor_SMD:C_0603_1608Metric,
2,C41 C51,C,1n 100V,Capacitor_SMD:C_0603_1608Metric,
4,C42 C45 C52 C55,C,100n 50V,Capacitor_SMD:C_0805_2012Metric,
3,C46 C56 C62,C,100n/50V,Capacitor_SMD:C_0603_1608Metric,
2,C47 C57,C,4.7n,Capacitor_SMD:C_0402_1005Metric,
2,C48 C58,C,100p C0G,Capacitor_SMD:C_0402_1005Metric,
1,C61,C,2.2u 50V,Capacitor_SMD:C_0805_2012Metric,
1,D1,TVS_BI,SMDJ36CA,Diode_SMD:D_SMC,
3,D2 D60 D61,TVS3301,TVS3301DRBR,HMT500_260313A:Texas_DRB0008A_PadFloat,
1,D3,SCHOTTKY,PMEG10010ELR,Diode_SMD:D_SOD-123F,
2,D30 D40,TVS1401,TVS1401DRBR,HMT500_260313A:Texas_DRB0008A_PadFloat,
2,D41 D51,BAS70-04,BAS70-04,Package_TO_SOT_SMD:SOT-23,
1,FB1,FB,600R@100MHz,Inductor_SMD:L_0603_1608Metric,
1,GDT1,GDT,2035-25-SM,HMT500_260313A:GDT_Bourns_2035-xx-SM,
1,J1,CONN_GH8,SM08B-GHS-TB,Connector_JST:JST_GH_SM08B-GHS-TB_1x08-1MP_P1.25mm_Horizontal,
1,J2,CONN_SWD,TC2030-IDC-NL,Connector:Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical,
1,J3,CONN_SH4,SM04B-SRSS-TB,Connector_JST:JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal,
1,J5,CONN_CH,CHASSIS wire,HMT500_260313A:SolderWire_Chassis_D0.6mm,
1,L1,CMC,CMC 1mH 0.8A,Inductor_SMD:L_CommonMode_Wuerth_WE-SL2,
1,L2,L,10uH,HMT500_260313A:L_SXN_SMNR4020,
1,L3,L,22uH,HMT500_260313A:L_SXN_SMNR4020,
1,R1,R,4.7R 1W 5%,Resistor_SMD:R_2512_6332Metric,
1,R2,R,1M HV,Resistor_SMD:R_1206_3216Metric,
1,R3,R,845k 1%,Resistor_SMD:R_0603_1608Metric,
1,R4,R,97.6k 1%,Resistor_SMD:R_0603_1608Metric,
1,R5,R,35.7k 1%,Resistor_SMD:R_0603_1608Metric,
1,R6,R,82k 1%,Resistor_SMD:R_0603_1608Metric,
1,R8,R,118k 1%,Resistor_SMD:R_0402_1005Metric,
2,R9 R52,R,22.1k 1%,Resistor_SMD:R_0402_1005Metric,
4,R10 R11 R33 R60,R,10k,Resistor_SMD:R_0402_1005Metric,
4,R12 R13 R31 R41,R,100k,Resistor_SMD:R_0402_1005Metric,
1,R14,R,100k 1%,Resistor_SMD:R_0402_1005Metric,
1,R15,R,10k 1%,Resistor_SMD:R_0402_1005Metric,
3,R17 R18 R20,R,1k,Resistor_SMD:R_0402_1005Metric,
1,R19,R,4.02k 0.1% 25ppm,Resistor_SMD:R_0603_1608Metric,
2,R30 R40,R,10R pulse,Resistor_SMD:R_2512_6332Metric,
2,R32 R42,R,15k 0.1% 25ppm,Resistor_SMD:R_0603_1608Metric,
2,R34 R44,R,10R,Resistor_SMD:R_0402_1005Metric,
1,R51,R,422k 1%,Resistor_SMD:R_0402_1005Metric,
1,U1,TPS2660,TPS26600PWPR,Package_SO:HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask2.46x2.31mm_ThermalVias,
2,U2 U15,LMR51606,LMR51606YFDBVR,Package_TO_SOT_SMD:SOT-23-6,
1,U3,TPS7A2033,TPS7A2033PDBVR,Package_TO_SOT_SMD:SOT-23-5,
1,U4,STM32G0B1CxTx,STM32G0B1CCT6,Package_QFP:LQFP-48_7x7mm_P0.5mm,
1,U5,PCAP04,PCAP04-AQFM-24,Package_DFN_QFN:QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm,
1,U6,ADS1220,ADS1220IPWR,Package_SO:TSSOP-16_4.4x5mm_P0.65mm,
2,U7 U8,DAC8760,DAC8760IPWP,Package_SO:HTSSOP-24-1EP_4.4x7.8mm_P0.65mm_EP3.2x5mm,
2,U9 U10,TPS26611,TPS26611DDFR,Package_TO_SOT_SMD:SOT-23-8,
1,U11,THVD2450,THVD2410DGKR,Package_SO:VSSOP-8_3.0x3.0mm_P0.65mm,
2,U12 U13,OPA197,OPA197IDBVR,Package_TO_SOT_SMD:SOT-23-5,
1,U14,74LVC2G32,SN74LVC2G32DCUR,Package_SO:VSSOP-8_2.3x2mm_P0.5mm,

## Code that names these connections

File hardware/kicad/gen_hmt500.py (part):

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ic("TPS7A2033", left=[("1", "IN", PI), ("3", "EN", I)], right=[("5", "OUT", PO), ("4", "NC", NC)],
   bottom=[("2", "GND", PI)], w=6, desc="TI TPS7A2033 3.3V LDO, SOT-23-5")
ic("STM32G0B1CxTx",
   left=[("10", "PF2-NRST", B), ("1", "PC13", B), ("2", "PC14", B), ("3", "PC15", B), ("8", "PF0", B), ("9", "PF1", B),
         ("30", "PC6", B), ("31", "PC7", B), ("38", "PD0", B), ("39", "PD1", B), ("40", "PD2", B), ("41", "PD3", B)],
   right=[(n, nm, B) for n, nm in (("11", "PA0"), ("12", "PA1"), ("13", "PA2"), ("14", "PA3"), ("15", "PA4"),
                                   ("16", "PA5"), ("17", "PA6"), ("18", "PA7"), ("28", "PA8"), ("29", "PA9"),
                                   ("32", "PA10"), ("33", "PA11"), ("34", "PA12"), ("35", "PA13"),
                                   ("36", "PA14-BOOT0"), ("37", "PA15"))] +
         [(n, f"PB{i}", B) for i, n in enumerate(["19", "20", "21", "42", "43", "44", "45", "46", "47", "48", "22",
                                                  "23", "24", "25", "26", "27"])],
   top=[("4", "VBAT", PI), ("6", "VDD", PI), ("5", "VREF+", PI)],
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   top=[("1", "VCC", P)], bottom=[("5", "GND", P)], w=12, prefix="J", desc="Tag-Connect TC2030 SWD")
ic("CONN_SH4", right=[("1", "SENS_1", P), ("2", "SENS_2", P), ("3", "PT+", P), ("4", "PT-", P)], w=6, prefix="J",
   desc="JST SH 1.0 mm 4-pin side-entry (right angle) header. Sensor harness W-1 direct from HTX99R connector (MK sensor + Pt1000 2-wire)")
ic("PCAP04", left=[("24", "PC2", P), ("1", "PC3", P), ("22", "PC0", P), ("20", "PC4", P), ("21", "PC5", P),
                   ("23", "PC1", P), ("19", "PCAUX", P), ("6", "PT0REF", P), ("5", "PT1", P), ("7", "PTOUT", P)],
   right=[("9", "SSN", I), ("16", "SCK", I), ("15", "MOSI", I), ("10", "MISO", T), ("11", "PG5", O),
          ("12", "PG2", B), ("17", "PG3", B), ("18", "PG4", B), ("3", "VDD18", P), ("13", "IIC_EN", I)],
   top=[("4", "VDD33", PI), ("14", "VDD33", PI)], ts=3, bottom=[("2", "GND", PI), ("8", "GND", PI), ("25", "EP", P)],
   w=10, rows=12, desc="ScioSense PCAP04 capacitance-to-digital, QFN24 4x4 (datasheet SC-001050-DS-6). VDD18 >= 4.7 uF, VDD33 >= 10 uF; INTN on PG5")
ic("ADS1220", left=[("10", "AIN1", P), ("11", "AIN0/REFP1", P), ("6", "AIN3/REFN1", P), ("7", "AIN2", P)],
   right=[("1", "SCLK", I), ("2", "~{CS}", I), ("16", "DIN", I), ("15", "DOUT/~{DRDY}", T), ("14", "~{DRDY}", O),
          ("3", "CLK", I)],
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S.gl("NRST", S.P("C21", "1"), "U", length=1)
S.gnd_stub(S.P("C21", "2"))
S.box(118, 7, 134, 27, "RESET")
S.text("PWR_FLT: internal pull-up (PB7)", (118.5, 24.9), 1.27)
S.text("SGOOD low = OK -> PA0/PA4 (ADC)", (118.5, 26.3), 1.27)
# v0.9: 리셋 중 떠 있는 입력 고정 — DAC LATCH 10k 풀업 (SCLK 게이트 닫힘), CS 100k 풀업 (ADS1220 9.1.5)
for i, (ref, val, net) in enumerate([("R10", "10k", "DAC1_LATCH"), ("R11", "10k", "DAC2_LATCH"),
                                    ("R12", "100k", "CS_ADC"), ("R13", "100k", "CS_CDC")]):
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    S.sup_stub("+3V3", S.P(ref, "1"))
    S.gl(net, S.P(ref, "2"), "D", length=1)
S.box(112, 29, 140, 46, "PULL-UPS")
sd = S.P("U4", "35")                              # SWD 패드: PA13·PA14와 같은 줄에 두고 곧은 선
S.place("J2", "CONN_SWD", "TC2030-IDC-NL", "Connector:Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical",
        98, sd[1] - S.dy + 1, nets={"1": "+3V3", "2": "SWDIO", "4": "SWCLK", "3": "NRST", "5": "GND"})
S.wa(sd, S.P("J2", "2"))
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S.gnd_stub(S.P("J2", "5"))
S.box(86, sd[1] - S.dy - 7, 110, sd[1] - S.dy + 7, "SWD")
S.box(6, 62, 48, 85, "MCU NOTES (STM32G0B1)")
for i, t in enumerate(["BOOT0 shares PA14/SWCLK - no pull-down.",
                       "Option bytes: nBOOT_SEL=1, nBOOT0=1, IWDG_SW=0, RDP 1",
                       "  -> in-house RS-485 bootloader 0x08000000 (dec. #31).",
                       "VDDA = VDD (LQFP48); VREF+ tied to +3V3 (C20).",
                       "PCB temp (mid): internal sensor, ADC ch TS + TS_CAL.",
                       "Cortex-M0+: no SWO (J2 pin 6 NC).",
                       "Same die as DP2000 (G0B1CCT6); T3 = -40..125 C.",
                       "VIN_SENSE (PB0 ADC_IN8) = VIN_P / 11."]):
    S.text(t, (7, 66 + 2.3 * i), 1.27)

part_table(S, 6, 86, [
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    S.gl(net, S.P("J3", num), "R", length=1)
S.box(2, 37, 21, 52, "SENSOR HEAD  J3")
S.text("harness W-1 from HTX99R, JST SH 1.0", (2.5, 50.8), 1.27)
# ── PCAP04: 센서선은 라벨, 기준 C22는 PC0·PC1에 곧게 ──
S.place("U5", "PCAP04", "PCAP04-AQFM-24", "Package_DFN_QFN:QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm", 52, 19, nets={
    "22": "CREF_A", "23": "CREF_B", "24": "SENS_C1", "1": "SENS_C2", "9": "CS_CDC", "16": "CDC_SCK",
    "15": "CDC_MOSI", "10": "CDC_MISO", "11": "CDC_INT", "13": "GND", "4": "+3V3A", "14": "+3V3A", "3": "CDC_V18",
    "2": "GND", "8": "GND", "25": "GND"})
S.gl("SENS_C1", S.P("U5", "24"), "L", length=1)
S.gl("SENS_C2", S.P("U5", "1"), "L", length=1)
pc0 = S.P("U5", "22")
S.v2("C22", "C", "330p C0G 2%", FP["C0603"], pc0[0] - S.dx - 3, pc0[1] - S.dy, "CREF_A", "CREF_B")
S.wa(S.P("C22", "1"), pc0)
S.wa(S.P("C22", "2"), S.P("U5", "23"))
for num in ("20", "21", "19", "6", "5", "7", "12", "17", "18"):   # 미사용: PC4·PC5·PCAUX·PT·PG2–4 개방
    S.nc(S.P("U5", num))
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S.wa(vd, S.P("C25", "1"))
S.gnd_stub(S.P("C25", "2"))
S.box(28, 5, 74, 34, "CAPACITIVE HUMIDITY SENSOR  (IST MK)  ->  PCAP04")
S.text("Floating single mode (DC-free, datasheet 7.2): C22 on PC0/PC1, sensor on PC2/PC3. Own SPI3.", (28.5, 33.3), 1.27)
# ── ADS1220: 필터 R17·R18은 입력 핀에 곧게, 기준저항 R19는 REFP0–REFN0 사이에 곧게 ──
S.place("U6", "ADS1220", "ADS1220IPWR", "Package_SO:TSSOP-16_4.4x5mm_P0.65mm", 52, 56, nets={
    "11": "PT_P", "10": "PT_SP_F", "7": "PT_SN_F", "1": "SPI_SCK", "2": "CS_ADC", "16": "SPI_MOSI",
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        "need gated SCLK (datasheet 8.5.1.5, Fig. 8-9).",
        "SPI2 mode 3 (CPOL 1, CPHA 1): SCK idles high, so the",
        "OR gate gives no extra edge at LATCH low/high.",
        "DACn_SCLK = DAC_SCK OR DACn_LATCH (PB10 / PB11).",
        "DIN and SDO shared (SDO 3-state after LATCH).",
        "ALARM: open drain, wired-OR, R33 10k pull-up;",
        "  which channel -> read status register.",
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S.text("VAO = 0.8 V x (1 + 422k/22.1k) = 16.08 V (15.5-16.6 V). LMR51606 FPWM 1.1 MHz, max duty 98 %.", (4.5, 23.4), 1.27)
S.text("Load 2 x (DAC 27 + OPA197 1.3 + TPS26611 1.75 mA) = 60 mA. C46/C56 at U9/U10 pin 6.", (4.5, 24.8), 1.27)
S.text("VIN_P < ~17 V: VAO follows VIN_P (dropout). 24 mA x 500 ohm OK down to VIN ~15.8 V.", (4.5, 26.2), 1.27)
# ── 전원 전압 감시: VIN_P / 11 → PB0 (ADC_IN8), 32.6 V → 2.96 V ──
S.v2("R14", "R", "100k 1%", FP["R0402"], 72, 10, "VIN_P", "VIN_SENSE")
S.sup_stub("VIN_P", S.P("R14", "1"))
S.v2("R15", "R", "10k 1%", FP["R0402"], 72, 16, "VIN_SENSE", "GND")
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S.w((72, 16), (82, 16), (90, 16))
S.gl("VIN_SENSE", S.o((90, 16)), "R", length=0)
S.box(69, 5, 104, 26, "SUPPLY MONITOR")
S.text("VIN_SENSE = VIN_P / 11 -> PB0 (ADC_IN8)", (69.5, 25.0), 1.27)
# v0.9: 검토 권장 DNP 자리(DAC 부스트, HSE 크리스털, 센서선 ESD)는 효과 있는 위치(DAC 핀·MCU OSC 핀·J3 옆)에
#   빈자리가 없어 넣지 않음 (결정 #32) — 대안은 아래 메모
S.box(4, 30, 104, 58, "OPTIONS NOT FITTED ON PCB")
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    ("R51, R52", "422k / 22.1k 1%", "VAO 설정", "0.8 V × (1 + 422/22.1) = 16.08 V"),
    ("C61, C62, C63", "2.2u 50V / 100n / 100n", "입력·부트스트랩", "VIN 핀 옆 입력 C, CB–SW 100 nF"),
    ("C46, C56", "100n/50V", "+Vs 바이패스", "C46 → U9 6번, C56 → U10 6번 핀 옆"),
    ("R14, R15, C30", "100k / 10k / 100n", "전원 전압 감시", "VIN_P / 11 → PB0 ADC (UVLO 8.9 V ~ DAC 최소 10 V 사이 판정)"),
])

# ════════════════════════════ 출력 ════════════════════════════
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        ("Outputs: RS-485 Modbus RTU + 2x analog (4-20 mA / 0-20 mA / 0-10 V / 0-5 V selectable).  Supply 12-28 V DC.", 1.4, False),
        ("v0.11: stocked resistors R1/R3/R4/R5/R6; R3 845k, R5 35.7k, R6 82k; see decision #57.", 1.4, False),
        ("v0.10: AO D30/D40 TVS1401 +/-14 V. AO +/-28/30 V continuous miswiring is NOT guaranteed (#41).", 1.4, False),
        ("Power symbols: GND, +3V3, +3V3A (analog 3.3 V), +5V, VIN_P (protected input), CHASSIS.  Inter-sheet signals: global labels.", 1.4, False),
        ("History v0.3-v0.8 (MCU G0B1, JST harness, DAC8760/TPS26611 datasheet pinouts, RTN isolation, gated DAC SCLK ...): docs/decision-log.md #9-#26.", 1.4, False),
        ("v0.9: 3-pass review (docs/hw/final-review-260313A.md): OVP 32.6 V (R5 36.5k); AO supply VAO 16.1 V buck U15 (DAC AVDD, TPS26611 +Vs; dec. #37, IVS320 AO); D3 series Schottky; RS-485 TVS D60/D61; D2 -> TVS3301; eFuse IN C2; buck CIN;", 1.4, False),
        ("      RS485_DE 10k pull-down (in-house bootloader, dec. #31); THVD2410; X7R only; R2 HV 1206; SGOOD -> PA0/PA4; CS_CDC -> PA15; VIN_SENSE PB0;", 1.4, False),
        ("      LATCH/CS pull-ups; OPA197 V+ = DAC AVDD; R31/R41 100k; SWD no-connect flags removed; sheet Aux: +Vs clamp, VIN monitor (DAC boost / HSE / sensor ESD: no room, dec. #32).", 1.4, False),
        ("Footprints: KiCad 7.0.11 library + project library HMT500_260313A (GDT Bourns 2035-xx-SM, TVS3301 pad floating).", 1.4, False),
        ("표기 규칙: 부품번호 = 굵은 글자 (R1, U4) / 부품값 = 보통 글자 (10k, DAC8760) / 전원 네트 = 기울인 글자 (+3V3, VIN_P)", 1.4, False),
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
File hardware/mech/m12_specification.py:

"""HMT500 P-204 M12 선정 사양서. 공통 기구 치수로 검토 외형도 작성."""
import argparse,sys,json
from pathlib import Path
from reportlab.pdfgen import canvas
from reportlab.pdfbase import pdfmetrics
from reportlab.pdfbase.ttfonts import TTFont
from reportlab.lib.units import mm
from reportlab.lib.colors import HexColor
sys.path.insert(0,str(Path(__file__).resolve().parent))
import hmt500_params as P
ROOT=Path(__file__).resolve().parents[2]
p=argparse.ArgumentParser();p.add_argument('--output',type=Path,default=ROOT/'hardware/mech/out/m12');p.add_argument('--font-dir',type=Path,default=Path.home()/'Library/Fonts');args=p.parse_args();args.output.mkdir(parents=True,exist_ok=True)
for n,f in [('KR','NanumGothic-Regular.ttf'),('KRB','NanumGothic-Bold.ttf')]:pdfmetrics.registerFont(TTFont(n,str(args.font_dir/f)))
out=args.output/'HMT500_M12_외형도포함_선정사양서_RevA.pdf';c=canvas.Canvas(str(out),pagesize=(420*mm,297*mm));c.setTitle('HMT500 M12 외형도 포함 선정 사양서 Rev A')
def t(x,y,s,z=10,b=False,color='#183247'):
 c.setFillColor(HexColor(color));c.setFont('KRB' if b else 'KR',z);c.drawString(x*mm,y*mm,s)
def line(x,y,xx,yy,color='#294557'):
 c.setStrokeColor(HexColor(color));c.setLineWidth(.25*mm);c.line(x*mm,y*mm,xx*mm,yy*mm)
def rect(x,y,w,h,color='#edf3f6'):
 c.setFillColor(HexColor(color));c.setStrokeColor(HexColor('#294557'));c.rect(x*mm,y*mm,w*mm,h*mm,fill=1,stroke=1)
def dim(x1,x2,y,label):
 line(x1,y,x2,y)
 for x in [x1,x2]:line(x-1,y-1,x+1,y+1)
 t((x1+x2)/2-pdfmetrics.stringWidth(label,'KR',9)/mm/2,y+2,label,9)
def page(n,title):
 c.setStrokeColor(HexColor('#294557'));c.rect(10*mm,10*mm,400*mm,277*mm)
 t(18,274,title,19,True);t(18,263,'HMT500-P-204  |  Rev A  |  2026-10-02  |  기구 Rev I / PCB A5-R1',10)
 line(10,26,410,26);t(18,16,'선정·견적 검토용 / 구매품 품번 미확정 / 단위 mm / 축척 없음 (NTS)',9);t(371,16,f'{n} / 2',10)
page(1,'M12 8핀 커넥터 — 외형·장착 조건')
t(18,251,'접속부 M12×1과 장착부 M16×1.5는 서로 다른 나사입니다.',12,True)
# Dimensioned project envelope, x=77 mounting face at drawing X=160.
s=6;face=160;cy=191
X=lambda v:face+(v-77)*s
rect(X(71),cy-8*s,6*s,16*s,'#e5edf1')
rect(X(77),cy-10*s,4*s,20*s,'#d7e6ee')
rect(X(81),cy-6*s,11*s,12*s,'#e5edf1')
# Diagram is positioned below title (top at 251); upper labels go beside it.
for xx in [72,73,74,75,76]:line(X(xx),cy-8*s,X(xx),cy+8*s,'#b1bec7')
for xx in range(82,92):line(X(xx),cy-6*s,X(xx),cy+6*s,'#b1bec7')
c.setDash(2*mm,1*mm);line(85,cy,248,cy);line(face,124,face,254);c.setDash()
t(26,224,'장치 내부',12,True);t(254,224,'장치 외부 / 상대 케이블 접속',12,True)
t(22,210,'장착 수나사: M16×1.5',10,True);line(95,208,X(73),202)
t(257,207,'접속 수나사: M12×1',11,True);line(250,205,X(86),200)
t(257,191,'형식: A-coded / 8핀 / Male',11,True)
t(257,176,'어깨 외경: Ø20 이하',11,True);line(249,176,X(79),cy-50)
t(257,164,'표현된 외형은 현 기구 모델입니다.',9)
t(257,156,'표준이 커넥터 몸체 전체 치수를',9);t(257,150,'정하는 것은 아닙니다.',9)
dim(X(71),X(77),121,'6 이하');dim(X(77),X(81),121,'4*');dim(X(81),X(92),121,'11*')
dim(X(77),X(92),109,'외부 돌출 15*')
t(21,133,'기준면 A: 엔드캡 뒤 끝면 x=77',9);line(104,135,face,145)
t(21,101,'* 4 / 11 / 15는 현재 모델 치수이며 선정품 실측값·표준 치수가 아닙니다.',10,True,'#ad491c')
line(18,94,402,94)
for i,(a,b) in enumerate([('장착 암나사','엔드캡 M16×1.5-6H, 모델 x71–77 (길이 6). 구매품 체결·씰 형상 대조 필요.'),('내부 여유','PCB 뒤끝 x69 → 모델 커넥터 안쪽 끝 x71: 축 방향 2 mm. 납땜 핀·수축튜브 돌출은 별도.'),('공구 공간','어깨 Ø20 조건에서 M3 경사 주입 공구 여유 0.625 mm. 어깨 확대 시 재검사.'),('밀봉·고정','O링/가스켓 형상, 장착 토크, 회전 방지, 체결 유효 길이: 선정품 도면으로 확인 필요.'),('선정 자료','공급사 2D 치수도·STEP·단자 방향도 요청. 안쪽 단자 전체 형상과 외부 돌출 길이를 포함할 것.')]):
 t(20,84-i*11,a,10,True);t(63,84-i*11,b,10)
c.showPage()
page(2,'M12 8핀 커넥터 — 전기·하네스·구매 사양')
t(18,249,'HMT500 핀 배정 (표준 공통 기능 배정이 아닌 본 제품 배정)',12,True)
pins=[('1','예비 / PCB NC'),('2','RS485_B_EXT'),('3','RS485_A_EXT'),('4','OUT1_EXT'),('5','OUT2_EXT'),('6','GND_IN / 전원 −'),('7','예비 / PCB NC'),('8','VIN_EXT / 전원 +')]
pl=json.loads((ROOT/'hardware/kicad/HMT500(ED260313A)/placement.json').read_text());j=next(q for q in pl['parts'] if q['ref']=='J1');nets={p['n']:p['net'] for p in j['pads']}
for k,v in [('2','RS485_B_EXT'),('3','RS485_A_EXT'),('4','OUT1_EXT'),('5','OUT2_EXT'),('6','GND_IN'),('8','VIN_EXT')]:assert nets[k]==v
for i,(num,net) in enumerate(pins):
 y=237-i*10;t(22,y,num,10,True);t(38,y,net,10);t(125,y,'→ J1.'+num,10);line(20,y-3,167,y-3,'#ced9df')
t(181,249,'선정 조건 및 현재 상태',12,True)
rows=[('접속 형식','M12 A-coded, 8핀 수형, 직선, 전면 장착'),('장착 나사','M16×1.5 (PG9·M16×1 등과 혼용 불가)'),('제품 사용 전압','12–28 V DC / 최대 28 V'),('커넥터 정격','30 V DC 이상 적용 여부 확인; 아래 참고품은 30 V'),('허용 전류','선정품·접점별·배선 규격으로 확인 필요'),('방수·온도','제품 요구와 체결 조건 확정 후 검증; 현재 보증 등급 미확정'),('하네스 W-2',f"8심 AWG28 PTFE, 현재 {P.HARNESS2['length']:g}±2 mm, JST GHR-08V-S"),('단자·배선','납땜형 또는 지정 리드선형. 실제 길이·피복·핀별 선색 확인'),('공통 주의','1·7번은 8심에 포함, PCB NC. 샤시는 별도 W-3 연결')]
for i,(a,b) in enumerate(rows):t(181,237-i*9,a,9,True);t(220,237-i*9,b,9)
t(20,142,'핀 배열의 정면/배선면 방향·키 위치는 선정품 제조사 도면을 따릅니다. 본 표를 물리적 핀 위치도로 사용하지 마십시오.',10,True,'#ad491c')
line(18,134,402,134);t(18,124,'제조사 공식 참고품 — 채택품 또는 무수정 호환품으로 승인한 것은 아닙니다.',12,True)
t(20,112,'[1] Phoenix Contact 1436424 · SACC-E-M12MS-8CON-M16/0,5 P',11,True)
t(20,103,'8핀 Male / A-coded / M16×1.5 전면 장착 / 30 V AC·DC / 2 A / 0.25 mm² 리드선 0.5 m.',10)
t(20,94,'현재 W-2의 AWG28·40 mm와 다릅니다. 외형·씰·내부 돌출·JST 압착 적합성을 별도로 확인해야 합니다.',10)
u1='https://www.phoenixcontact.com/en-fr/products/device-connector-front-mounting-sacc-e-m12ms-8con-m16-05-p-1436424'
t(20,85,'제조사 제품 페이지 및 외형도 열기 [1]',9,color='#1665a4');c.linkURL(u1,(20*mm,83*mm,170*mm,90*mm),relative=0)
t(20,72,'[2] binder 76 0831 0011 00008-0200 · M12-A series 763',11,True)
t(20,63,'8핀 Male / M16×1.5 / 30 V / 2 A (UL 1.5 A) / 리드선 AWG24·0.2 m. 현재 W-2와 배선 규격이 다름.',10)
u2='https://www.binder-usa.com/us-en/products/automation-technology/m12-a/76-0831-0011-00008-0200-m12-a-male-panel-mount-connector-8-unshielded-single-wires-ip68-ul-m16x15'
t(20,54,'제조사 제품 페이지·외형도·접속면 핀 배열 열기 [2]',9,color='#1665a4');c.linkURL(u2,(20*mm,52*mm,200*mm,59*mm),relative=0)
t(20,39,'발행 근거: hmt500_params.py / PCB J1 연결 정보 / 제조사 공식 페이지(2026-10-02 확인). 실제 M Connect 품번: 확인 필요.',9)
c.showPage();c.save();print(out)
